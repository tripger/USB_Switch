# Keil uVision project USB_Switch.uvprojx, settings and files
target Eval_USB (ARM-ADS)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB_Switch
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\bsp\L476G_EVAL;..\bsp\Common\Board;..\drivers\Common;..\drivers\stmpe811;..\drivers\stmpe1600
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Src
    ./: app.c
  group BSP
    ../bsp/L476G_EVAL/: stm32l476g_eval.c stm32l476g_eval_io.c adc_stm32l476g_eval.c buttons_stm32l476g_eval.c led_stm32l476g_eval.c
  group Drivers
    ../drivers/stmpe811/: stmpe811.c
    ../drivers/stmpe1600/: stmpe1600.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476ZGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476ZGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:Event Recorder 1.4.0, Device:STM32Cube HAL:ADC 1.9.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SRAM 1.9.0, Device:Startup 1.3.1
